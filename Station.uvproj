# Keil uVision project Station.uvproj, settings and files
target Station (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Station +hex
  AfterMake: fromelf --bin -o "E:\工具生成\固件更新\综合分站\station.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429xx,STARTADDR=0x08000000
  c include: .\SYSTEM;.\TOOLS\MALLOC;.\W5500;.\TOOLS\JSON;.\TOOLS\TASKMANGER;.\FATFS\exfuns;.\FATFS\src\option;.\FATFS\src;.\MB85RC256;.\TOOLS\CRCMAKER;.\SENSORS\SENSORFACTORY;.\PAGES\SYSCONFIG;.\TOOLS\FILERECV;.\TOOLS\LOGRECORDER;.\TOOLS\DATETOOL;.\PAGES\PAGEMANGER;.\PAGES\MAINPAGE;.\PAGES;.\PAGES\FONTS;.\PAGES;.\PAGES\CurValuePage;.\PAGES\SYSINFO;.\EMWIN\emWin\Lib;.\EMWIN\emWin\Config;.\EMWIN\emWin\Include;.\EMWIN\emWin\OS;.\EMWIN\STemWinHZ\EMWINFONT;.\PAGES\STATUSBAR;.\PAGES\JSONTEST;.\PAGES\LINKLIST;.\PAGES\HISTORYCURVE;.\PAGES\POWEROFFLOG;.\BEANS;.\PAGES\TASKLIST;.\WT2031;.\VS1003;.\APP\INC;.\HARDWARE\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYSTEM
    ./SYSTEM/: startup_stm32f429xx.s sys.c
  group APP
    ./APP/: main.c
    ./APP/PUBLIC/: Public.c
    ./APP/NETPRO/: NetPro.c
    ./APP/NETDATAPRO/: NetDataPro.c
    ./APP/CANPRO/: CanPro.c
    ./APP/CONFIG/: Config.c
    ./APP/DEBUG/: DebugPro.c
    ./APP/KEYPRO/: KeyPro.c
    ./APP/MP3PRO/: MP3Pro.c
    ./APP/TOLKPRO/: TolkPro.c
    ./APP/BOARDCASTCMD/: BoardCastCmd.c
  group HARDWARE
    ./HARDWARE/Mcu/: Mcu.c
    ./HARDWARE/CAN/: Can.c
    ./HARDWARE/UART/: Uart.c
    ./HARDWARE/W5500SPI/: W5500Spi.c
    ./HARDWARE/SDRAM/: sdram.c
    ./HARDWARE/SDIO/: sdio_sdcard.c
    ./HARDWARE/RNG/: rng.c
    ./HARDWARE/SD2068/: SD2068.c
    ./HARDWARE/KEY/: Key.c
    ./HARDWARE/LCDSPI/: LcdSpi.c
    ./HARDWARE/LCD/: ltdc.c tftlcd.c
  group TOOLS
    ./TOOLS/MALLOC/: malloc.c
    ./TOOLS/JSON/: cJSON.c
    ./TOOLS/TASKMANGER/: TaskManger.c
    ./TOOLS/CRCMAKER/: CrcMaker.c
    ./TOOLS/FILERECV/: FileRecv.c
    ./TOOLS/LOGRECORDER/: LogRecorder.c
    ./TOOLS/DATETOOL/: DateTool.c
  group W5500
    ./W5500/: Socket.c W5500.c
  group WT2031
    ./WT2031/: WT2031.c
  group VS1003
    ./VS1003/: VS1003.c
  group MBRC256
    ./MB85RC256/: FmInit.c
  group FATFS
    ./FATFS/exfuns/: exfuns.c fattester.c
    ./FATFS/src/: diskio.c ff.c
    ./FATFS/src/option/: cc936.c
  group SENSORS
    ./SENSORS/SENSORFACTORY/: SensorFactory.c
  group PAGES
    ./PAGES/PAGEMANGER/: PageManger.c
    ./PAGES/MAINPAGE/: MainPage.c
    ./PAGES/SYSINFO/: SysInfoPage.c
    ./PAGES/CurValuePage/: CurValuePage.c
    ./PAGES/STATUSBAR/: StatusBar.c
    ./PAGES/JSONTEST/: JsonTest.c
    ./PAGES/LINKLIST/: LinkListPage.c
    ./PAGES/HISTORYCURVE/: HistoryCurvePage.c
    ./PAGES/POWEROFFLOG/: PowerOffLogPage.c
    ./PAGES/TASKLIST/: TaskListPage.c
  group EMWIN_LIB
    ./EMWIN/emWin/Lib/: GUI_CM4F_L.lib
  group EMWIN_CONFIG
    ./EMWIN/emWin/Config/: GUI_X_Touch_Analog.c GUIConf.c LCDConf_FlexColor_Template.c GUIDRV_Template.c
    ./EMWIN/emWin/OS/: GUI_X.c
  group EMWIN_HZ
    ./EMWIN/STemWinHZ/EMWINFONT/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c fontupd.c
  group BEANS
    ./BEANS/: PowerOffLogBean.c
